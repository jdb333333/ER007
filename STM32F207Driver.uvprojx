# Keil uVision project STM32F207Driver.uvprojx, settings and files
target ECR-99 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F207ZG STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x00100000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ECR-99 +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F2XX,USE_STM322xG_EVAL,USE_USB_OTG_FS,USE_EMBEDDED_PHY,CASE_ECR99,CASE_GPRS,FOR_DEBUG,CASE_ASCIIDISPLAY,CASE_ETHERNET,TWO_SDCARDS,NAND_DISK,
  c include: .\USER\inc;.\Libraries\CMSIS;.\Libraries\CMSIS\Include;.\Libraries\STM32F2xx_StdPeriph_Driver\inc;.\Libraries\STM32_USB_OTG_Driver\inc;.\Libraries\STM32_USB_Device_Library\Core\inc;.\Libraries\STM32_USB_Device_Library\Class\MSC\inc;.\Libraries\STM32_USB_HOST_Library\Core\inc;.\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;.\Libraries\STM32_USB_HOST_Library\Class\HID\inc;.\Utilities\Third_Party\fat_fs\inc;.\Utilities\USB_APP\inc;.\Print;.\Demo;.\EosCLED;.\Libraries\STM32F2x7_ETH_Driver\inc;.\EOSTCPIP\inc;.\Utilities\Third_Party\lwip_v1.3.2\src\include;.\Utilities\Third_Party\lwip_v1.3.2\src\include\lwip;.\Utilities\Third_Party\lwip_v1.3.2\src\include\netif;.\Utilities\Third_Party\lwip_v1.3.2\src\include\ipv4;.\Utilities\Third_Party\lwip_v1.3.2\port\STM32F2x7;.\Utilities\Third_Party\lwip_v1.3.2\port\STM32F2x7\Standalone
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group USER
    ./USER/: asciifonts.c fsmc_sram.c flashb.c interface.c KeyBoard.c monitor.c nor_flash.c pwr_ctrl.c spi_m25p80.c stm32f2xx_it.c usart.c USB_Application.c lcd_160x.c lcd_ht1621.c lcd_st7565r.c lcd_st7567_od.c lcd_st7567_cd.c Ethernet_app.c sdio_sd.c nand.c ftl.c malloc.c spi_sd.c spi_sd_2nd.c spi_w25qxx.c ECR_IAP.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f2xx.c startup_stm32f2xx.s
  group STM32F2xx_StdPeriph_Driver
    ./Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group STM32F2x7_ETH_Driver
    ./Libraries/STM32F2x7_ETH_Driver/src/: stm32f2x7_eth.c
  group USB Driver
    ./Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c usb_hcd.c usb_hcd_int.c
  group USB Device
    ./Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ./Libraries/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group USB Host
    ./Libraries/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ./Libraries/STM32_USB_HOST_Library/Class/HID/src/: usbh_hid_core.c usbh_hid_keybd.c usbh_hid_mouse.c
    ./Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c
  group USB_APP
    ./Utilities/USB_APP/: usb_bsp.c usbd_desc.c usbd_storage_msd.c usbd_usr.c usbh_msc_usr.c
  group Print
    ./Print/: Photo_abbigl.c Photo_appetito.c Photo_caf.c Photo_caffe.c Photo_carneval.c Photo_cornetto.c Photo_cucina.c Photo_donna.c Photo_eutron.c Photo_fiori.c Photo_gelato.c Photo_jolly.c Photo_MALTA.c Photo_mamma.c Photo_natale.c Photo_panama.c Photo_pane.c Photo_papa.c Photo_pasqua.c Photo_pesce.c Photo_risparmi.c Photo_salumi.c Photo_selfdef.c Photo_sport.c Photo_vacanze.c Photo_valentin.c Photo_vuoto.c Print_DEF.c Print_Main.c
  group FatFS
    ./Utilities/Third_Party/fat_fs/src/: ff.c diskio.c
    ./Utilities/Third_Party/fat_fs/src/option/: cc936.c
  group LwIP
    ./Utilities/Third_Party/lwip_v1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ./Utilities/Third_Party/lwip_v1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ./Utilities/Third_Party/lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ./Utilities/Third_Party/lwip_v1.3.2/src/netif/: etharp.c loopif.c slipif.c
    ./Utilities/Third_Party/lwip_v1.3.2/port/STM32F2x7/Standalone/: ethernetif.c
  group tcp_client
    ./EOSTCPIP/: tcp_client.c netconf.c stm32f2x7_eth_bsp.c
  group EOSCLCD
    ./EOSCLCD/: USBDiskApp.c Agree.c Balance.c Barcode.c Buffer.c Chinaapp.c ChnDIsp.c CHNInput.c CHNMess.c Clerk.c Computer.c Correc.c Currency.c Depart.c Discount.c Drawer.c ePOSCard.c ExtModules.c Firmkey.c Fiscal.c Fixed.c Flowbill.c Format.c General.c Gprs.c Group.c Hardtest.c ICCard.c ICCardBlock.c Initappl.c Kp.c Main.c MEMORY.c Menu.c Modifier.c OFFPrice.c Pb.c Pbbuffer.c Plu.c Pora.c Port.c Print.c Progdump.c Progopt.c Program.c PyCode.c Report2.c Report.c Salper.c Search.c Tax.c Tender.c Timer.c QR_Encode.c EJournal.c
target ECR-100F (ARM-ADS)
  device: STM32F207ZG STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: as above
  output: ECR-100F +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F2XX,USE_STM322xG_EVAL,USE_USB_OTG_FS,USE_EMBEDDED_PHY,CASE_ECR100F,CASE_GPRS,FOR_DEBUG,CASE_ASCIIDISPLAY,SPI_SD,TWO_SDCARDS,CASE_ETHERNET,
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
target ECR-100S (ARM-ADS)
  device: STM32F207ZG STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: as above
  output: ECR-100S +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F2XX,USE_STM322xG_EVAL,USE_USB_OTG_FS,USE_EMBEDDED_PHY,CASE_ECR100S,CASE_GPRS,FOR_DEBUG,SPI_SD,TWO_SDCARDS,CASE_ETHERNET,
  c include: .\USER\inc;.\Libraries\CMSIS;.\Libraries\CMSIS\Include;.\Libraries\STM32F2xx_StdPeriph_Driver\inc;.\Libraries\STM32_USB_OTG_Driver\inc;.\Libraries\STM32_USB_Device_Library\Core\inc;.\Libraries\STM32_USB_Device_Library\Class\MSC\inc;.\Libraries\STM32_USB_HOST_Library\Core\inc;.\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;.\Libraries\STM32_USB_HOST_Library\Class\HID\inc;.\Utilities\Third_Party\fat_fs\inc;.\Utilities\USB_APP\inc;.\Print;.\Demo;.\EosCLED;.\Libraries\STM32F2x7_ETH_Driver\inc;.\tcp_echo_client\inc;.\Utilities\Third_Party\lwip_v1.3.2\src\include;.\Utilities\Third_Party\lwip_v1.3.2\src\include\lwip;.\Utilities\Third_Party\lwip_v1.3.2\src\include\netif;.\Utilities\Third_Party\lwip_v1.3.2\src\include\ipv4;.\Utilities\Third_Party\lwip_v1.3.2\port\STM32F2x7;.\Utilities\Third_Party\lwip_v1.3.2\port\STM32F2x7\Standalone
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
target ER-260F (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F207ZG STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: as above
  output: ER-260F +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F2XX,USE_STM322xG_EVAL,USE_USB_OTG_FS,USE_EMBEDDED_PHY,CASE_ER260F,CASE_GPRS,FOR_DEBUG,CASE_ASCIIDISPLAY,
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
target MCR-30 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F207ZG STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: as above
  output: MCR30 +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F2XX,USE_STM322xG_EVAL,USE_USB_OTG_FS,USE_EMBEDDED_PHY,CASE_MCR30,CASE_GPRS,FOR_DEBUG,TWO_SDCARDS,NAND_DISK,CASE_ETHERNET,
  c include: .\USER\inc;.\Libraries\CMSIS;.\Libraries\CMSIS\Include;.\Libraries\STM32F2xx_StdPeriph_Driver\inc;.\Libraries\STM32_USB_OTG_Driver\inc;.\Libraries\STM32_USB_Device_Library\Core\inc;.\Libraries\STM32_USB_Device_Library\Class\MSC\inc;.\Libraries\STM32_USB_HOST_Library\Core\inc;.\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;.\Libraries\STM32_USB_HOST_Library\Class\HID\inc;.\Utilities\Third_Party\fat_fs\inc;.\Utilities\USB_APP\inc;.\Print;.\Libraries\STM32F2x7_ETH_Driver\inc;.\EOSTCPIP\inc;.\Utilities\Third_Party\lwip_v1.3.2\src\include;.\Utilities\Third_Party\lwip_v1.3.2\src\include\lwip;.\Utilities\Third_Party\lwip_v1.3.2\src\include\netif;.\Utilities\Third_Party\lwip_v1.3.2\src\include\ipv4;.\Utilities\Third_Party\lwip_v1.3.2\port\STM32F2x7;.\Utilities\Third_Party\lwip_v1.3.2\port\STM32F2x7\Standalone;.\EOSCLCD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
target MCR-007 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F207ZG STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: as above
  output: MCR007 +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F2XX,USE_STM322xG_EVAL,USE_USB_OTG_FS,USE_EMBEDDED_PHY,CASE_MCR30,CASE_GPRS,CASE_ETHERNET,OD_4ROW
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
software components: CMSIS:CORE 4.3.0
